# Keil uVision project ISP_RS485.uvprojx, settings and files
target ISP_RS485 (6240000::V6.24::ARMCLANG)
  device: NUC121SC2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) IROM2(0x00100000,0x1200) IROM3(0x00200000,0x200)
  output: ISP_RS485
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC121\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\NUC121\Source\ARM\LDROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../common/: startup_NUC121_isp.c
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c
