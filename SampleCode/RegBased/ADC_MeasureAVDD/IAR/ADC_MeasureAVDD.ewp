# IAR project ADC_MeasureAVDD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC121AE series Nuvoton NUC121AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC121\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_MeasureAVDD.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: ADC_MeasureAVDD.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/IAR/: startup_NUC121.s
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c
  group User
    ../: main.c
