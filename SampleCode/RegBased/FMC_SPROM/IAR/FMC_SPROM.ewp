# IAR project FMC_SPROM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC121AE series Nuvoton NUC121AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC121\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_SPROM.bin
  ILINK.IlinkOutputFile: FMC_SPROM.out
  ILINK.IlinkIcfFile: FMC_SPROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/IAR/: startup_NUC121.s
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c SPROM.c
