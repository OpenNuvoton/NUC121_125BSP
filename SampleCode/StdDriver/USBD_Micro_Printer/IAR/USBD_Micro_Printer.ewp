# IAR project USBD_Micro_Printer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC121AE series Nuvoton NUC121AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\NUC121\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Micro_Printer.bin
  ILINK.IlinkOutputFile: USBD_Micro_Printer.out
  ILINK.IlinkIcfFile: USBD_Micro_Printer.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/IAR/: startup_NUC121.s
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c
  group User
    ../: descriptors.c main.c micro_printer.c
