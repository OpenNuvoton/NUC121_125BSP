# Keil uVision project USCI_UART_TxRx_Function.uvprojx, settings and files
target USCI_UART_TxRx_Function (6220000::V6.22::ARMCLANG)
  device: NUC121SC2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: USCI_UART_TxRx_Function
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: DEBUG_PORT=UUART0
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC121\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\NUC121\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c usci_uart.c
    ../: myretarget.c
