# IAR project I2S_PDMA_NAU8822.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC121AE series Nuvoton NUC121AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC121\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: I2S_PDMA_NAU8822.bin
  ILINK.IlinkOutputFile: I2S_PDMA_NAU8822.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/IAR/: startup_NUC121.s
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c pdma.c retarget.c spi_i2s.c sys.c uart.c
  group User
    ../: main.c
