# Keil uVision project BPWM_DoubleBuffer_PeriodLoadingMode.uvproj, settings and files
target BPWM_DoubleBuffer_PeriodLoadingMode (ARM-ADS)
  device: NUC121SC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: BPWM_DoubleBuffer_PeriodLoadingMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC121\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC121.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c bpwm.c
