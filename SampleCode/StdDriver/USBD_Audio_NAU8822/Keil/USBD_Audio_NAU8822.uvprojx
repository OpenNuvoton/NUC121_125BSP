# Keil uVision project USBD_Audio_NAU8822.uvprojx, settings and files
target USBD_Audio_NAU8822 (6240000::V6.24::ARMCLANG)
  device: NUC121SC2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) IROM2(0x00100000,0x1200) IROM3(0x00200000,0x200)
  output: USBD_Audio_NAU8822
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: Stack_Size=0x500
  c misc: -Wconditional-uninitialized
  c include: .\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC121\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\NUC121\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.c
  group User
    ../: descriptors.c main.c usbd_audio.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c i2c.c gpio.c uart.c spi_i2s.c
